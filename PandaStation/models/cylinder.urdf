Commit message: full stack pick and place videos done

File: PandaStation/models/cylinder.urdf (robot description, URDF)
Before this commit: robot hand, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=2 radius=0.03; visual cylinder length=2 radius=0.03
