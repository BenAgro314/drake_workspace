Commit message: done cylinders

File: PandaStation/models/billard.urdf (robot description, URDF)
Before this commit: robot puck, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0.0525; visual sphere radius=0.0525
